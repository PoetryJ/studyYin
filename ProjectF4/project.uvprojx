# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\Libraries\Startup;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\User\inc;D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.1.0\CMSIS\Include;D:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APL
    ./User/src/: main.c stm32f4xx_it.c can.c delay.c dma.c led.c pwm.c sys.c time.c usart.c
  group LIB
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_can.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group STARTUP
    ./Libraries/Startup/: startup_stm32f4xx.s
software components: CMSIS:CORE 5.4.0
